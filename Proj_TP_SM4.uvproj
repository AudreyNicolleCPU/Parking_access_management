# Keil uVision project Proj_TP_SM4.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Sim_SM4
  c flags: Optimize=8 SizeSpeed=1
  group Programmes Source 1
    ./: Lib_TP_SM.asm Lib_VosSP_SM4.asm Main_SM4.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: EXE_SM4
  c flags: Optimize=8 SizeSpeed=1
